* Infinite grid of resistors, N = 12, M = 13
R0 0 1 1.0
R1 1 2 1.0
R2 2 3 1.0
R3 3 4 1.0
R4 4 5 1.0
R5 5 6 1.0
R6 6 7 1.0
R7 7 8 1.0
R8 8 9 1.0
R9 9 10 1.0
R10 10 11 1.0
R11 11 12 1.0
R12 13 14 1.0
R13 14 15 1.0
R14 15 16 1.0
R15 16 17 1.0
R16 17 18 1.0
R17 18 19 1.0
R18 19 20 1.0
R19 20 21 1.0
R20 21 22 1.0
R21 22 23 1.0
R22 23 24 1.0
R23 24 25 1.0
R24 26 27 1.0
R25 27 28 1.0
R26 28 29 1.0
R27 29 30 1.0
R28 30 31 1.0
R29 31 32 1.0
R30 32 33 1.0
R31 33 34 1.0
R32 34 35 1.0
R33 35 36 1.0
R34 36 37 1.0
R35 37 38 1.0
R36 39 40 1.0
R37 40 41 1.0
R38 41 42 1.0
R39 42 43 1.0
R40 43 44 1.0
R41 44 45 1.0
R42 45 46 1.0
R43 46 47 1.0
R44 47 48 1.0
R45 48 49 1.0
R46 49 50 1.0
R47 50 51 1.0
R48 52 53 1.0
R49 53 54 1.0
R50 54 55 1.0
R51 55 56 1.0
R52 56 57 1.0
R53 57 58 1.0
R54 58 59 1.0
R55 59 60 1.0
R56 60 61 1.0
R57 61 62 1.0
R58 62 63 1.0
R59 63 64 1.0
R60 65 66 1.0
R61 66 67 1.0
R62 67 68 1.0
R63 68 69 1.0
R64 69 70 1.0
R65 70 71 1.0
R66 71 72 1.0
R67 72 73 1.0
R68 73 74 1.0
R69 74 75 1.0
R70 75 76 1.0
R71 76 77 1.0
R72 78 79 1.0
R73 79 80 1.0
R74 80 81 1.0
R75 81 82 1.0
R76 82 83 1.0
R77 83 84 1.0
R78 84 85 1.0
R79 85 86 1.0
R80 86 87 1.0
R81 87 88 1.0
R82 88 89 1.0
R83 89 90 1.0
R84 91 92 1.0
R85 92 93 1.0
R86 93 94 1.0
R87 94 95 1.0
R88 95 96 1.0
R89 96 97 1.0
R90 97 98 1.0
R91 98 99 1.0
R92 99 100 1.0
R93 100 101 1.0
R94 101 102 1.0
R95 102 103 1.0
R96 104 105 1.0
R97 105 106 1.0
R98 106 107 1.0
R99 107 108 1.0
R100 108 109 1.0
R101 109 110 1.0
R102 110 111 1.0
R103 111 112 1.0
R104 112 113 1.0
R105 113 114 1.0
R106 114 115 1.0
R107 115 116 1.0
R108 117 118 1.0
R109 118 119 1.0
R110 119 120 1.0
R111 120 121 1.0
R112 121 122 1.0
R113 122 123 1.0
R114 123 124 1.0
R115 124 125 1.0
R116 125 126 1.0
R117 126 127 1.0
R118 127 128 1.0
R119 128 129 1.0
R120 130 131 1.0
R121 131 132 1.0
R122 132 133 1.0
R123 133 134 1.0
R124 134 135 1.0
R125 135 136 1.0
R126 136 137 1.0
R127 137 138 1.0
R128 138 139 1.0
R129 139 140 1.0
R130 140 141 1.0
R131 141 142 1.0
R132 143 144 1.0
R133 144 145 1.0
R134 145 146 1.0
R135 146 147 1.0
R136 147 148 1.0
R137 148 149 1.0
R138 149 150 1.0
R139 150 151 1.0
R140 151 152 1.0
R141 152 153 1.0
R142 153 154 1.0
R143 154 155 1.0
R144 0 13 1.0
R145 1 14 1.0
R146 2 15 1.0
R147 3 16 1.0
R148 4 17 1.0
R149 5 18 1.0
R150 6 19 1.0
R151 7 20 1.0
R152 8 21 1.0
R153 9 22 1.0
R154 10 23 1.0
R155 12 25 1.0
R156 13 26 1.0
R157 14 27 1.0
R158 15 28 1.0
R159 16 29 1.0
R160 17 30 1.0
R161 18 31 1.0
R162 19 32 1.0
R163 20 33 1.0
R164 21 34 1.0
R165 22 35 1.0
R166 24 37 1.0
R167 25 38 1.0
R168 26 39 1.0
R169 27 40 1.0
R170 28 41 1.0
R171 29 42 1.0
R172 30 43 1.0
R173 31 44 1.0
R174 32 45 1.0
R175 33 46 1.0
R176 34 47 1.0
R177 36 49 1.0
R178 37 50 1.0
R179 38 51 1.0
R180 39 52 1.0
R181 40 53 1.0
R182 41 54 1.0
R183 42 55 1.0
R184 43 56 1.0
R185 44 57 1.0
R186 45 58 1.0
R187 46 59 1.0
R188 48 61 1.0
R189 49 62 1.0
R190 50 63 1.0
R191 51 64 1.0
R192 52 65 1.0
R193 53 66 1.0
R194 54 67 1.0
R195 55 68 1.0
R196 56 69 1.0
R197 57 70 1.0
R198 58 71 1.0
R199 60 73 1.0
R200 61 74 1.0
R201 62 75 1.0
R202 63 76 1.0
R203 64 77 1.0
R204 65 78 1.0
R205 66 79 1.0
R206 67 80 1.0
R207 68 81 1.0
R208 69 82 1.0
R209 70 83 1.0
R210 72 85 1.0
R211 73 86 1.0
R212 74 87 1.0
R213 75 88 1.0
R214 76 89 1.0
R215 77 90 1.0
R216 78 91 1.0
R217 79 92 1.0
R218 80 93 1.0
R219 81 94 1.0
R220 82 95 1.0
R221 84 97 1.0
R222 85 98 1.0
R223 86 99 1.0
R224 87 100 1.0
R225 88 101 1.0
R226 89 102 1.0
R227 90 103 1.0
R228 91 104 1.0
R229 92 105 1.0
R230 93 106 1.0
R231 94 107 1.0
R232 96 109 1.0
R233 97 110 1.0
R234 98 111 1.0
R235 99 112 1.0
R236 100 113 1.0
R237 101 114 1.0
R238 102 115 1.0
R239 103 116 1.0
R240 104 117 1.0
R241 105 118 1.0
R242 106 119 1.0
R243 108 121 1.0
R244 109 122 1.0
R245 110 123 1.0
R246 111 124 1.0
R247 112 125 1.0
R248 113 126 1.0
R249 114 127 1.0
R250 115 128 1.0
R251 116 129 1.0
R252 117 130 1.0
R253 118 131 1.0
R254 120 133 1.0
R255 121 134 1.0
R256 122 135 1.0
R257 123 136 1.0
R258 124 137 1.0
R259 125 138 1.0
R260 126 139 1.0
R261 127 140 1.0
R262 128 141 1.0
R263 129 142 1.0
R264 130 143 1.0
R265 132 145 1.0
R266 133 146 1.0
R267 134 147 1.0
R268 135 148 1.0
R269 136 149 1.0
R270 137 150 1.0
R271 138 151 1.0
R272 139 152 1.0
R273 140 153 1.0
R274 141 154 1.0
R275 142 155 1.0
R276 144 157 1.0
R277 145 158 1.0
R278 146 159 1.0
R279 147 160 1.0
R280 148 161 1.0
R281 149 162 1.0
R282 150 163 1.0
R283 151 164 1.0
R284 152 165 1.0
R285 153 166 1.0
R286 154 167 1.0

V1 11 8 dc 1V

.control
op
print i(v1)
* print all
.endc

* Grid size = 12 * 13
* # resistors = 287
