* Infinite grid of resistors, N = 2, M = 3

* Horizontal resistors
R0 0 1 1
R1 1 2 1
* ---
R2 3 4 1
R3 4 5 1
* Vertical resistors
* ---
R4 0 3 1
R5 1 4 1
R6 2 5 1

V1 3 2 dc 1V

.control
op
print i(v1)
* print all
.endc

* Grid size = 2 * 3
* # resistors = 7
